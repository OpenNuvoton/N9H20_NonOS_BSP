# Keil uVision project N9H20K3_SpiLoader_gzip.uvproj, settings and files
target N9H20K3_GPM1006D0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20K3_SpiLoader_gzip_GPM1006D0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: _N9H20K3_ __LCM_QVGA__ CONFIG_BZIP2
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K3.scf
  link misc: --entry Reset_Go
  group Src
    ../ziplib/: zlib.c
    ../: cmd_bootm.c heap.s main.c SpiRead.c stack.s standalone.c vectors.s wb_init.s
  group Lib
    ../../../BSP/Library/IPLib/: N9H20_GPIO.lib N9H20_SYS.lib N9H20_SPU.lib N9H20_VPOST_GIANTPLUS_GPM1006D.lib
target N9H20K3_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_SpiLoader_gzip_NoLCM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: _N9H20K3_ __No_LCM__ CONFIG_BZIP2
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K3.scf
  link misc: --entry Reset_Go
