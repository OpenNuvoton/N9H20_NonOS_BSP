# Keil uVision project SpiLoader_Security_gzip.uvproj, settings and files
target N9H20K1_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20K1_SpiLoader(S)_gzip_NoLCM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: _N9H20K1_ __No_LCM__ CONFIG_BZIP2 __Security__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K1.scf
  link misc: --entry Reset_Go
  group Src
    ../: cmd_bootm.c heap.s main.c SpiRead.c stack.s standalone.c vectors.s wb_init.s Rootkey.c
    ../ziplib/: zlib.c
  group Lib
    ../../../BSP/Library/IPLib/: N9H20_GPIO.lib N9H20_SYS.lib N9H20_SPU.lib N9H20_SPI_SecureIC.lib N9H20_VPOST_GIANTPLUS_GPM1006D.lib N9H20_VPOST_FW043TFT_480x272.lib N9H20_VPOST_FW050TFT_800x480.lib
target N9H20K3_GPM1006D0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_SpiLoader(S)_gzip_GPM1006D0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: _N9H20K3_ __LCM_QVGA__ CONFIG_BZIP2 __Security__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K3.scf
  link misc: --entry Reset_Go
target N9H20K3_FW043TFT (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_SpiLoader(S)_gzip_FW043TFT
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: _N9H20K3_ __LCM_480x272__ CONFIG_BZIP2 __Security__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K3.scf
  link misc: --entry Reset_Go
target N9H20K3_FW050TFT (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_SpiLoader(S)_gzip_FW050TFT
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: _N9H20K3_ __LCM_800x480__ CONFIG_BZIP2 __Security__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K3.scf
  link misc: --entry Reset_Go
target N9H20K3_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_SpiLoader(S)_gzip_NoLCM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: _N9H20K3_ __No_LCM__ CONFIG_BZIP2 __Security__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K3.scf
  link misc: --entry Reset_Go
target N9H20K5_GPM1006D0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_SpiLoader(S)_gzip_GPM1006D0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: _N9H20K5_ __LCM_QVGA__ CONFIG_BZIP2 __Security__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K5_FW043TFT (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_SpiLoader(S)_gzip_FW043TFT
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: _N9H20K5_ __LCM_480x272__ CONFIG_BZIP2 __Security__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K5_FW050TFT (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_SpiLoader(S)_gzip_FW050TFT
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: _N9H20K5_ __LCM_800x480__ CONFIG_BZIP2 __Security__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K5_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_SpiLoader(S)_gzip_NoLCM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: _N9H20K5_ __No_LCM__ CONFIG_BZIP2 __Security__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K6_GPM1006D0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_SpiLoader(S)_gzip_GPM1006D0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: _N9H20K6_ __LCM_QVGA__ CONFIG_BZIP2 __Security__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K6.scf
  link misc: --entry Reset_Go
target N9H20K6_FW043TFT (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_SpiLoader(S)_gzip_FW043TFT
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: _N9H20K6_ __LCM_480x272__ CONFIG_BZIP2 __Security__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K6.scf
  link misc: --entry Reset_Go
target N9H20K6_FW050TFT (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_SpiLoader(S)_gzip_FW050TFT
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: _N9H20K6_ __LCM_800x480__ CONFIG_BZIP2 __Security__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K6.scf
  link misc: --entry Reset_Go
target N9H20K6_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_SpiLoader(S)_gzip_NoLCM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: _N9H20K6_ __No_LCM__ CONFIG_BZIP2 __Security__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K6.scf
  link misc: --entry Reset_Go
