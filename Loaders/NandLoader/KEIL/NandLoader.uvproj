# Keil uVision project NandLoader.uvproj, settings and files
target N9H20K1_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20K1_NANDLoader_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K1.scf
  link misc: --entry Reset_Go
  group Src
    ../../NandLoader/: Depop.c heap.s NandDrv.c NandLoader.c stack.s standalone.c vectors.s wb_config.c wb_init.s wb_uart.c
  group user_defined_func
    ../user_define/: user_define_func.c
    ../../../BSP/Library/IPLib/: N9H20_SYS.lib N9H20_VPOST_GIANTPLUS_GPM1006D.lib
target N9H20K1_120MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_NANDLoader_120MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_120__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K1.scf
  link misc: --entry Reset_Go
target N9H20K1_96MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_NANDLoader_96MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_96__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K1.scf
  link misc: --entry Reset_Go
target N9H20K1_192MHz_Logo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_NANDLoader_192MHz_Logo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__ __USER_DEFINE_FUNC
  c include: ..\;..\..\..\BSP\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K1.scf
  link misc: --entry Reset_Go
target N9H20K1_No_RTC (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_NANDLoader_No_RTC
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__ __DISABLE_RTC__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K1.scf
  link misc: --entry Reset_Go
target N9H20K3_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_NANDLoader_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K3.scf
  link misc: --entry Reset_Go
target N9H20K3_120MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_NANDLoader_120MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_120__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K3.scf
  link misc: --entry Reset_Go
target N9H20K3_96MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_NANDLoader_96MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_96__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K3.scf
  link misc: --entry Reset_Go
target N9H20K3_192_Logo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_NANDLoader_192_Logo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__ __USER_DEFINE_FUNC
  c include: ..; ..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K3.scf
  link misc: --entry Reset_Go
target N9H20K3_No_RTC (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_NANDLoader_No_RTC
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__ __DISABLE_RTC__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K3.scf
  link misc: --entry Reset_Go
target N9H20K5_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_NANDLoader_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K5_120MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_NANDLoader_120MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_120__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K5_96MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_NANDLoader_96MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_96__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K5_192_Logo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_NANDLoader_192_Logo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__ __USER_DEFINE_FUNC
  c include: ..; ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K5_No_RTC (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_NANDLoader_No_RTC
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__ __DISABLE_RTC__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K6_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_NANDLoader_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K6.scf
  link misc: --entry Reset_Go
target N9H20K6_120MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_NANDLoader_120MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_120__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K6.scf
  link misc: --entry Reset_Go
target N9H20K6_96MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_NANDLoader_96MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_96__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K6.scf
  link misc: --entry Reset_Go
target N9H20K6_192_Logo (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_NANDLoader_192_Logo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__ __USER_DEFINE_FUNC
  c include: ..; ..\..\..\BSP\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K6.scf
  link misc: --entry Reset_Go
target N9H20K6_No_RTC (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_NANDLoader_No_RTC
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__ __DISABLE_RTC__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\NandLoader_N9H20K6.scf
  link misc: --entry Reset_Go
