# Keil uVision project N9H20K3_NVTLoader.uvproj, settings and files
target N9H20K3_NAND_GPM1006D0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20K3_NVT_NAND_GPM1006D0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C copy "$L@L.bin" ..\..\binary
  c flags: Optim=1 wLevel=2
  c define: __GWMT9360A__ __LCM_QVGA__ N9H20K3
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K3.scf
  link misc: --entry Reset_Go
  group Src
    ../: avi.c heap.s main.c mass.c stack.s standalone.c vectors.s wb_init.s
  group Lib
    ../../../BSP/Library/IPLib/: N9H20_VPOST_FW043TFT_480x272.lib N9H20_VPOST_GIANTPLUS_GPM1006D.lib N9H20_UDC.lib N9H20_SYS.lib N9H20_SPU.lib N9H20_SIC.lib N9H20_MSC_SD_MP_PORT0.lib N9H20_MSC_NAND.lib N9H20_kpi_2x3.lib N9H20_JPEG.lib N9H20_gpio.lib
    ../../../BSP/Library/NVTFATLib/: N9H20_NVTFAT.lib
    ../../../BSP/Library/GNANDLib/: N9H20_GNAND.lib
    ../../../BSP/Library/AVILib/: N9H20_IMA_ADPCM.lib N9H20_AVI.lib
target N9H20K3_SD_GPM1006D0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_NVT_SDU0_GPM1006D0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C copy "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: __GWMT9360A__ __LCM_QVGA__ __ENABLE_SD_CARD_0__ N9H20K3
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K3.scf
  link misc: --entry Reset_Go
target N9H20K3_NAND_FW043TFT (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_NVT_NAND_FW043TFT
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C copy "$L@L.bin" ..\..\binary
  c flags: Optim=1 wLevel=2
  c define: __GWMT9360A__ __LCM_480x272__ N9H20K3
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K3.scf
  link misc: --entry Reset_Go
target N9H20K3_SD_FW043TFT (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_NVT_SDU0_FW043TFT
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C copy "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: __GWMT9360A__ __LCM_480x272__ __ENABLE_SD_CARD_0__ N9H20K3
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K3.scf
  link misc: --entry Reset_Go
