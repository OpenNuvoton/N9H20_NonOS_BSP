# Keil uVision project N9H20K1_SpiLoader_Security.uvproj, settings and files
target N9H20K1_GPM1006D0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20K1_SpiLoader(S)_GPM1006D0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: __GWMT9360A__ __LCM_QVGA__ __Security__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K1.scf
  link misc: --entry Reset_Go
  group Src
    ../: Rootkey.c heap.s main.c SpiRead.c stack.s standalone.c vectors.s wb_init.s
  group Lib
    ../../../BSP/Library/IPLib/: N9H20_SPU.lib N9H20_GPIO.lib N9H20_VPOST_GIANTPLUS_GPM1006D.lib N9H20_SYS.lib N9H20_SPI_SecureIC.lib
target N9H20K1_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_SpiLoader(S)_NoLCM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\binary
  c flags: Optim=3 wLevel=2
  c define: __No_LCM__ __Security__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\scat_N9H20K1.scf
  link misc: --entry Reset_Go
