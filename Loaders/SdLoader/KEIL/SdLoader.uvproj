# Keil uVision project SdLoader.uvproj, settings and files
target N9H20K1_SDLoader_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20K1_SDLoader_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader_N9H20K1.scf
  link misc: --entry Reset_Go
  group Src
    ../../SDLoader/: Depop.c heap.s sd.c SdLoader.c stack.s standalone.c vectors.s wb_config.c wb_init.s wb_uart.c
target N9H20K1_SDLoader_S605_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_SDLoader_S605_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__ _S605_
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader_N9H20K1.scf
  link misc: --entry Reset_Go
target N9H20K3_SDLoader_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_SDLoader_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader_N9H20K3.scf
  link misc: --entry Reset_Go
target N9H20K3_SDLoader_S605_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_SDLoader_S605_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__ _S605_
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader_N9H20K3.scf
  link misc: --entry Reset_Go
target N9H20K5_SDLoader_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_SDLoader_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K5_SDLoader_S605_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_SDLoader_S605_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__ _S605_
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader_N9H20K5.scf
  link misc: --entry Reset_Go
target N9H20K6_SDLoader_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_SDLoader_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader_N9H20K6.scf
  link misc: --entry Reset_Go
target N9H20K6_SDLoader_S605_192MHz (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_SDLoader_S605_192MHz
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: cmd /C move "$L@L.bin" ..\..\Binary
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: __UPLL_192__ _S605_
  c include: ..\..\..\BSP\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\SdLoader_N9H20K6.scf
  link misc: --entry Reset_Go
