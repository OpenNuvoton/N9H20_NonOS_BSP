# Keil uVision project FontLib.uvproj, settings and files
target Font_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20_Font_QVGA (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_
  c include: ..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../: Font.c
target Font_WQVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20_Font_WQVGA (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_
  c include: ..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target Font_VGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20_Font_VGA (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: _DEMO_VGA_
  c include: ..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target Font_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20_Font_WVGA (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_
  c include: ..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
