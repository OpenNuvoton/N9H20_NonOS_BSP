# Keil uVision project USBDLib.uvproj, settings and files
target Standard mode (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20_UDC (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: __USBD_STANDARD_MODE__
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../../USBD/: usbd.c
target Full speed mode (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20_UDC_Fullspeed (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: __USBD_FULL_SPEED_MODE__
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target High speed mode (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20_UDC_Highspeed (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: __USBD_HIGH_SPEED_MODE__
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
