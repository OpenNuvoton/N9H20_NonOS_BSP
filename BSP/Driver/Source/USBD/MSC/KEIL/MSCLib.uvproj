# Keil uVision project MSCLib.uvproj, settings and files
target NAND (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20_MSC_NAND (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: TEST_SM
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group Src
    ../../MSC/: mscd.c
target SD_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20_MSC_SD_PORT0 (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: SD_PORT0 TEST_SD
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SD_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20_MSC_SD_PORT1 (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: SD_PORT1 TEST_SD
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SD_PORT2 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20_MSC_SD_PORT2 (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: SD_PORT2 TEST_SD
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SD_MultiPartition_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20_MSC_SD_MP_PORT0 (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: SD_PORT0 SD_MULTIPLE_PARTITIONS TEST_SD
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SD_MultiPartition_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20_MSC_SD_MP_PORT1 (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: SD_PORT1 SD_MULTIPLE_PARTITIONS TEST_SD
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SD_MultiPartition_PORT2 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20_MSC_SD_MP_PORT2 (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: SD_PORT2 SD_MULTIPLE_PARTITIONS TEST_SD
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target RAM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20_MSC_RAM (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: TEST_RAM
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target All_Storage_SD_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20_MSC_ALL_SD_PORT0 (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: SD_PORT0 TEST_SM TEST_SD __ALL_STORAGE__ TEST_RAM
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target All_Storage_SD_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20_MSC_ALL_SD_PORT1 (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: SD_PORT1 TEST_SM TEST_SD __ALL_STORAGE__ TEST_RAM
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target All_Storage_SD_MP_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20_MSC_ALL_SD_MP_PORT0 (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: SD_PORT0 SD_MULTIPLE_PARTITIONS TEST_SM TEST_SD __ALL_STORAGE__ TEST_RAM
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target All_Storage_SD_MP_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20_MSC_ALL_SD_MP_PORT1 (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: SD_PORT1 SD_MULTIPLE_PARTITIONS TEST_SM TEST_SD __ALL_STORAGE__ TEST_RAM
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
target SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20_MSC_SPI (library)
  AfterMake: cmd /C move "$L@L.lib" ..\..\..\..\..\Library\IPLib
  c flags: Optim=1 wLevel=2
  c define: TEST_SPI
  c include: ..\..\..\..\Include
  memory RVCT9: RAM 0xf8002000 size 0x8000
