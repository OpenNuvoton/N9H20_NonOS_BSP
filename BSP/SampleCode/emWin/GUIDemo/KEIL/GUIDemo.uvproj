# Keil uVision project GUIDemo.uvproj, settings and files
target N9H20K5_NAND (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: GUIDemo_N9H20K5_NAND
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: fromelf.exe --bin --output "$P../Bin/@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: ..\..\..\..\Driver\Include;..\..\..\..\ThirdParty\emWin\Config;..\..\..\..\ThirdParty\emWin\Include;..\Application;..\tslib
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group Src
    ../: main.c wb_init.s standalone.c
  group Lib
    ../../../../Library/IPLib/: N9H20_SYS.lib N9H20_VPOST_GIANTPLUS_GPM1006D.lib N9H20_VPOST_FW050TFT_800x480.lib N9H20_VPOST_FW043TFT_480x272.lib N9H20_ADC.lib N9H20_SIC.lib N9H20_BLT.lib N9H20_JPEG.lib
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
    ../../../../Library/NVTFATLib/: N9H20_NVTFAT.lib
  group tslib
    ../tslib/: ts_calibrate.c fbutils.c testutils.c N9H20TouchPanel.c
  group GUI_Config
    ../../../../ThirdParty/emWin/Config/: LCDConf.c GUI_X.c LCDConf.h GUIConf.h
  group GUI_Lib
    ../../../../ThirdParty/emWin/Lib/: NUemWin_ARM9_Keil.lib
  group Application
    ../Application/: GUIConf.c GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
target N9H20K3_NAND (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: GUIDemo_N9H20K3_NAND
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c include: as above
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K5_SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: GUIDemo_N9H20K5_SD
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STORAGE_SD
  c include: as above
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
target N9H20K3_SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: GUIDemo_N9H20K3_SD
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STORAGE_SD
  c include: as above
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K5_NAND_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: GUIDemo_N9H20K5_NAND_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __800x480__
  c include: as above
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
target N9H20K5_NAND_480x272 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: GUIDemo_N9H20K5_NAND_480x272
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: fromelf.exe --bin --output "$P../Bin/@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: __480x272__
  c include: as above
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
target N9H20K5_SD_800x480 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: GUIDemo_N9H20K5_SD_800x480
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STORAGE_SD __800x480__
  c include: as above
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
target N9H20K5_SD_480x272 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: GUIDemo_N9H20K5_SD_480x272
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STORAGE_SD __480x272__
  c include: as above
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
