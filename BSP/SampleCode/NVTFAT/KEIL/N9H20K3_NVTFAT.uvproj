# Keil uVision project N9H20K3_NVTFAT.uvproj, settings and files
target N9H20K3_FAT_NAND (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NVTFAT_NAND_K3
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=2 wLevel=2
  c define: ENABLE_GNAND
  c include: ..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
  group Src
    ../: Demo_CommandShell.c NVTFAT_ERROR.C RAMDiskDriver.c standalone.c wb_init.s
  group Lib
    ../../../Library/NVTFATLib/: N9H20_NVTFAT.lib
    ../../../Library/IPLib/: N9H20_SIC.lib N9H20_SYS.lib
    ../../../Library/GNANDLib/: N9H20_GNAND.lib
    ../../../Library/USBHLib/: N9H20_USBH.lib
target N9H20K3_FAT_SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVTFAT_SD_K3
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: ENABLE_SD ENABLE_SD_ONE_PART
  c include: ..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H20K3\N9H20K3.sct
target N9H20K3_FAT_SD_TWO_PART (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVTFAT_SD2P_K3
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: ENABLE_SD_TWO_PART ENABLE_SD
  c include: ..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_FAT_SD_FOUR_PART (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVTFAT_SD4P_K3
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: ENABLE_SD_FOUR_PART ENABLE_SD
  c include: ..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_FAT_USBH (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVTFAT_USBH_K3
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: ENABLE_USB_HOST
  c include: ..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_FAT_RAM_SD (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NVTFAT_RAMSD_K3
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: ENABLE_RAM ENABLE_SD ENABLE_SD_ONE_PART
  c include: ..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
