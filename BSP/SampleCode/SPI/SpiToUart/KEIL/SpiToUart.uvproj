# Keil uVision project SpiToUart.uvproj, settings and files
target N9H20K1_SpiToUart (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20K1_SpiToUart
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry 0
  group Src
    ../: standalone.c wb_init.s SpiToUart.c
  group Lib
    ../../../../Library/IPLib/: N9H20_SPI.lib N9H20_SYS.lib N9H20_SPI_SPIToUART.lib
target N9H20K3_SpiToUart (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_SpiToUart
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K5_SpiToUart (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_SpiToUart
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
target N9H20K6_SpiToUart (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_SpiToUart
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
