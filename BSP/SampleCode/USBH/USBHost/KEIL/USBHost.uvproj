# Keil uVision project USBHost.uvproj, settings and files
target N9H20K1_USBH (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: USBH_K1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry 0
  group Src
    ../: main.c standalone.c usb_keyboard.c W99683.c wb_init.s
  group Lib
    ../../../../Library/USBHLib/: N9H20_USBH.lib
    ../../../../Library/IPLib/: N9H20_SYS.lib
    ../../../../Library/NVTFATlib/: N9H20_NVTFAT.lib
target N9H20K3_USBH (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: USBH_K3
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K5_USBH (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: USBH_K5
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
