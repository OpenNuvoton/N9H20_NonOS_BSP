# Keil uVision project N9H20K5_HID.uvproj, settings and files
target N9H20K5_HID_Transfer (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: HID_Transfer
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry Reset_Go
  group Src
    ../: main.c standalone.c wb_init.s HID.c
  group Lib
    ../../../../Library/IPLib/: N9H20_SYS.lib N9H20_UDC.lib
    ../: spi.c spiflash.c SpiRead.c
