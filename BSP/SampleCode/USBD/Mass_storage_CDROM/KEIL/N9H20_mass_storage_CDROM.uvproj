# Keil uVision project N9H20_mass_storage_CDROM.uvproj, settings and files
target N9H20K1_MSC_CDROM_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20K1_MSC_CDROM_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_CDROM_ONLY__ __RAM_DISK_ONLY__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry 0
  group Src
    ../: main.c standalone.c wb_init.s demo_wakeup.c
  group MSC Lib
    ../../../../Library/IPLib/: N9H20_MSC_CDROM_Only.lib N9H20_MSC_NAND_CDROM.lib N9H20_MSC_RAM_CDROM.lib N9H20_MSC_SD_MP_PORT0_CDROM.lib N9H20_MSC_SD_MP_PORT1_CDROM.lib N9H20_MSC_SD_MP_PORT2_CDROM.lib N9H20_MSC_SD_PORT0_CDROM.lib N9H20_MSC_SD_PORT1_CDROM.lib N9H20_MSC_SD_PORT2_CDROM.lib N9H20_MSC_SPI_CDROM.lib N9H20_MSC_ALL_SD_MP_PORT0_CDROM.lib N9H20_MSC_ALL_SD_MP_PORT1_CDROM.lib N9H20_MSC_ALL_SD_PORT0_CDROM.lib N9H20_MSC_ALL_SD_PORT1_CDROM.lib
  group Lib
    ../../../../Library/IPLib/: N9H20_SYS.lib N9H20_SIC.lib N9H20_SPI.lib N9H20_UDC.lib
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
    ../../../../Library/NVTFATlib/: N9H20_NVTFAT.lib
target N9H20K1_MSC_NAND_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_MSC_NAND_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND_ONLY__ __NAND__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry 0
target N9H20K1_MSC_SD_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_MSC_SD_PORT0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry 0
target N9H20K1_MSC_SD_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_MSC_SD_PORT1_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry 0
target N9H20K1_MSC_SD_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_MSC_SD_PORT2_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry 0
target N9H20K1_MSC_SD_MP_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_MSC_SD_MP_PORT0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry 0
target N9H20K1_MSC_SD_MP_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_MSC_SD_MP_PORT1_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry 0
target N9H20K1_MSC_SD_MP_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_MSC_SD_MP_PORT2_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry 0
target N9H20K1_MSC_SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_MSC_SPI
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SPI_ONLY__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry 0
target N9H20K3_MSC_CDROM_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_MSC_CDROM_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_CDROM_ONLY__ __RAM_DISK_ONLY__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_MSC_RamDiskOnly (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_MSC_RamDiskOnly
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_CDROM_ONLY__ __RAM_DISK_ONLY__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_MSC_NAND_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_MSC_NAND_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND_ONLY__ __NAND__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_MSC_SD_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_MSC_SD_PORT0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_MSC_SD_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_MSC_SD_PORT1_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_MSC_SD_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_MSC_SD_PORT2_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_MSC_SD_MP_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_MSC_SD_MP_PORT0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_MSC_SD_MP_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_MSC_SD_MP_PORT1_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_MSC_SD_MP_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_MSC_SD_MP_PORT2_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_MSC_All_Storage_SD_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_MSC_All_Storage_SD_PORT0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT0__ __SD__ __ALL_STORAGE__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_MSC_All_Storage_SD_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_MSC_All_Storage_SD_PORT1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT1__ __SD__ __ALL_STORAGE__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_MSC_All_Storage_SD_MP_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_MSC_All_Storage_SD_MP_PORT0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT0__ __SD__ __ALL_STORAGE__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_MSC_All_Storage_SD_MP_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_MSC_All_Storage_SD_MP_PORT1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT1__ __SD__ __ALL_STORAGE__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_MSC_SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_MSC_SPI
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SPI_ONLY__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K5_MSC_CDROM_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_MSC_CDROM_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_CDROM_ONLY__ __RAM_DISK_ONLY__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K5_MSC_RamDiskOnly (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_MSC_RamDiskOnly
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_CDROM_ONLY__ __RAM_DISK_ONLY__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K5_MSC_NAND_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_MSC_NAND_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND_ONLY__ __NAND__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K5_MSC_SD_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_MSC_SD_PORT0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K5_MSC_SD_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_MSC_SD_PORT1_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K5_MSC_SD_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_MSC_SD_PORT2_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K5_MSC_SD_MP_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_MSC_SD_MP_PORT0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K5_MSC_SD_MP_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_MSC_SD_MP_PORT1_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K5_MSC_SD_MP_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_MSC_SD_MP_PORT2_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K5_MSC_All_Storage_SD_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_MSC_All_Storage_SD_PORT0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT0__ __SD__ __ALL_STORAGE__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K5_MSC_All_Storage_SD_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_MSC_All_Storage_SD_PORT1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT1__ __SD__ __ALL_STORAGE__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K5_MSC_All_Storage_SD_MP_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_MSC_All_Storage_SD_MP_PORT0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT0__ __SD__ __ALL_STORAGE__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K5_MSC_All_Storage_SD_MP_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_MSC_All_Storage_SD_MP_PORT1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT1__ __SD__ __ALL_STORAGE__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K5_MSC_SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_MSC_SPI
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SPI_ONLY__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K6_MSC_CDROM_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_MSC_CDROM_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_CDROM_ONLY__ __RAM_DISK_ONLY__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K6_MSC_RamDiskOnly (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_MSC_RamDiskOnly
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __RAM_DISK_CDROM_ONLY__ __RAM_DISK_ONLY__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K6_MSC_NAND_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_MSC_NAND_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND_ONLY__ __NAND__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K6_MSC_SD_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_MSC_SD_PORT0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K6_MSC_SD_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_MSC_SD_PORT1_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K6_MSC_SD_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_MSC_SD_PORT2_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K6_MSC_SD_MP_PORT0_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_MSC_SD_MP_PORT0_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT0__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K6_MSC_SD_MP_PORT1_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_MSC_SD_MP_PORT1_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT1__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K6_MSC_SD_MP_PORT2_Only (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_MSC_SD_MP_PORT2_Only
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SD_PORT2__ __SD_ONLY__ __SD__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K6_MSC_All_Storage_SD_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_MSC_All_Storage_SD_PORT0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT0__ __SD__ __ALL_STORAGE__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K6_MSC_All_Storage_SD_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_MSC_All_Storage_SD_PORT1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT1__ __SD__ __ALL_STORAGE__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K6_MSC_All_Storage_SD_MP_PORT0 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_MSC_All_Storage_SD_MP_PORT0
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT0__ __SD__ __ALL_STORAGE__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K6_MSC_All_Storage_SD_MP_PORT1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_MSC_All_Storage_SD_MP_PORT1
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NAND__ __SD_PORT1__ __SD__ __ALL_STORAGE__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K6_MSC_SPI (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_MSC_SPI
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __SPI_ONLY__
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
  group added to the first target's files
    ../../../../Library//GNANDLib/: N9H20_GNAND.lib
  group left out of the first target's files
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
