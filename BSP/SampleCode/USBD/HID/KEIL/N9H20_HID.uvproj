# Keil uVision project N9H20_HID.uvproj, settings and files
target N9H20K1_Mouse_Pattern (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20K1_Mouse_Pattern
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: HID_MOUSE
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry Reset_Go
  group Src
    ../: main.c standalone.c wb_init.s HID.c demo_wakeup.c
  group Lib
    ../../../../Library/IPLib/: N9H20_UDC_Fullspeed.lib N9H20_GPIO.lib N9H20_KPI_2x3.lib N9H20_SYS.lib
target N9H20K1_Mouse_Keypad (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_Mouse_Keypad
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: HID_MOUSE HID_KEYPAD
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry Reset_Go
target N9H20K1_Keyboard_Pattern (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_Keyboard_Pattern
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: HID_KEYBOARD
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry Reset_Go
target N9H20K1_Keyboard_Keypad (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_Keyboard_Keypad
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 wLevel=2
  c define: HID_KEYBOARD HID_KEYPAD
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry Reset_Go
target N9H20K3_Mouse_Pattern (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_Mouse_Pattern
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: HID_MOUSE
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry Reset_Go
target N9H20K3_Mouse_Keypad (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_Mouse_Keypad
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: HID_MOUSE HID_KEYPAD
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry Reset_Go
target N9H20K3_Keyboard_Pattern (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_Keyboard_Pattern
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: HID_KEYBOARD
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry Reset_Go
target N9H20K3_Keyboard_Keypad (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_Keyboard_Keypad
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: HID_KEYBOARD HID_KEYPAD
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry Reset_Go
target N9H20K5_Mouse_Pattern (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_Mouse_Pattern
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: HID_MOUSE
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry Reset_Go
target N9H20K5_Mouse_Keypad (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_Mouse_Keypad
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: HID_MOUSE HID_KEYPAD
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry Reset_Go
target N9H20K5_Keyboard_Pattern (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_Keyboard_Pattern
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: HID_KEYBOARD
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry Reset_Go
target N9H20K5_Keyboard_Keypad (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_Keyboard_Keypad
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: HID_KEYBOARD HID_KEYPAD
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry Reset_Go
target N9H20K6_Mouse_Pattern (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_Mouse_Pattern
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: HID_MOUSE
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry Reset_Go
target N9H20K6_Mouse_Keypad (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_Mouse_Keypad
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: HID_MOUSE HID_KEYPAD
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry Reset_Go
target N9H20K6_Keyboard_Pattern (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_Keyboard_Pattern
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: HID_KEYBOARD
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry Reset_Go
target N9H20K6_Keyboard_Keypad (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_Keyboard_Keypad
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: HID_KEYBOARD HID_KEYPAD
  c include: ..\..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry Reset_Go
