# Keil uVision project ADC.uvproj, settings and files
target N9H20K1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20K1_ADC
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 wLevel=2
  c include: ..\..\..\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry 0
  group Src
    ../: main.c audioRecord.c standalone.c TouchPanel.c wb_init.s
  group Lib
    ../../../Library/IPLib/: N9H20_ADC.lib N9H20_SYS.lib N9H20_SIC.lib N9H20_EDMA.lib
    ../../../Library/NVTFATLib/: N9H20_NVTFAT.lib
    ../../../Library/GNANDLib/: N9H20_GNAND.lib
target N9H20K3 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_ADC
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 wLevel=2
  c include: ..\..\..\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K5 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_ADC
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 wLevel=2
  c include: ..\..\..\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
target N9H20K6 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_ADC
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 wLevel=2
  c include: ..\..\..\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
