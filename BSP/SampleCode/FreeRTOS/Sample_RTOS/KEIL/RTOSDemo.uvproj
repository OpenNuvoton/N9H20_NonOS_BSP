# Keil uVision project RTOSDemo.uvproj, settings and files
target N9H20K1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20K1_RTOSDemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Driver\Include;..\Startup;..\..\ARM9_N9H20;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\..\..\..\ThirdParty\FreeRTOS\Demo\Common\include
  asm define: N9H20K1
  asm include: ..\ARM9_N9H20
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K1\N9H20K1.sct
  link misc: --entry 0
  group Startup
    ../Startup/: wb_init.s standalone.c multithread.c main.c
  group Stadard Demo
    ../Demo/: PollQ_N9H2x.c BlockQ_N9H2x.c semtest_N9H2x.c dynamic_N9H2x.c
  group Lib
    ../../../../Library/IPLib/: N9H20_SYS_FreeRTOS.lib
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/: tasks.c list.c queue.c
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../ARM9_N9H20/: port.c portASM.s
target N9H20K3 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_RTOSDemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: as above
  asm define: N9H20K3
  asm include: ..\ARM9_N9H20
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K5 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_RTOSDemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: as above
  asm define: N9H20K5
  asm include: ..\ARM9_N9H20
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
target N9H20K6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_RTOSDemo
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: as above
  asm define: N9H20K6
  asm include: ..\ARM9_N9H20
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
