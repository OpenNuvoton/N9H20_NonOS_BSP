# Keil uVision project NVTFAT_FreeRTOS.uvproj, settings and files
target NVTFAT_FreeRTOS_NAND_N9H20K5 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20K5_NVTFAT_FreeRTOS_NAND
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: ..\..\..\..\Driver\Include;..\..\..\FreeRTOS\ARM9_N9H20;..\..\..\..\ThirdParty\FreeRTOS\Source\include;..\StartUp
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group Startup
    ../StartUp/: main.c wb_init.s standalone.c multithread.c Retarget.c
  group Lib
    ../../../../Library/IPLib/: N9H20_SIC.lib N9H20_SYS_FreeRTOS.lib
    ../../../../Library/GNANDLib/: N9H20_GNAND.lib
    ../../../../Library/NVTFATLib/: N9H20_NVTFAT_FREERTOS.lib
  group FreeRTOS
    ../../../../ThirdParty/FreeRTOS/Source/: tasks.c list.c queue.c
    ../../../FreeRTOS/ARM9_N9H20/: port.c portASM.s
    ../../../../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
target NVTFAT_FreeRTOS_SD_N9H20K5 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_NVTFAT_FreeRTOS_SD
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STORAGE_SD
  c include: as above
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
target NVTFAT_FreeRTOS_NAND_N9H20K6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_NVTFAT_FreeRTOS_NAND
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c include: as above
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
target NVTFAT_FreeRTOS_SD_N9H20K6 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_NVTFAT_FreeRTOS_SD
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STORAGE_SD
  c include: as above
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
