# Keil uVision project NandWriter.uvproj, settings and files
target N9H20K1_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20K1_NandWriter_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_ N9H20K1
  c include: ..\..\..\..\..\BSP\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H20K1\N9H20K1.sct
  link misc: --entry 0
  group Src
    ../../Src/: DrawFont.c nvtNandDrv.c ProcessIni.c ProcessOptionalIni.c standalone.c wb_init.s main.c
  group Lib
    ../../../../../BSP/Library/GNANDLib/: N9H20_GNAND.lib
    ../../../../../BSP/Library/IPLib//: N9H20_SIC.lib
    ../../../../../BSP/Library/NVTFATLib//: N9H20_NVTFAT.lib
    ../../../../../BSP/Library/IPLib/: N9H20_SYS.lib N9H20_GPIO.lib N9H20_VPOST_GIANTPLUS_GPM1006D.lib N9H20_Font_QVGA.lib N9H20_Font_WVGA.lib N9H20_Font_WQVGA.lib
target N9H20K1_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_NandWriter_WVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_ N9H20K1
  c include: ..\..\..\..\..\BSP\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H20K1\N9H20K1.sct
  link misc: --entry 0
target N9H20K1_WQVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K1_NandWriter_WQVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_ N9H20K1
  c include: ..\..\..\..\..\BSP\Driver\Include
  asm define: N9H20K1
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H20K1\N9H20K1.sct
  link misc: --entry 0
target N9H20K3_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_NandWriter_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_ N9H20K3
  c include: ..\..\..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_NandWriter_WVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_ N9H20K3
  c include: ..\..\..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K3_WQVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K3_NandWriter_WQVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_ N9H20K3
  c include: ..\..\..\..\..\BSP\Driver\Include
  asm define: N9H20K3
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H20K3\N9H20K3.sct
  link misc: --entry 0
target N9H20K5_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_NandWriter_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_ N9H20K5
  c include: ..\..\..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
target N9H20K5_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_NandWriter_WVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_ N9H20K5
  c include: ..\..\..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
target N9H20K5_WQVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_NandWriter_WQVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_ N9H20K5
  c include: ..\..\..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
target N9H20K6_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_NandWriter_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_ N9H20K6
  c include: ..\..\..\..\..\BSP\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
target N9H20K6_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_NandWriter_WVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_ N9H20K6
  c include: ..\..\..\..\..\BSP\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
target N9H20K6_WQVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K6_NandWriter_WQVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_ N9H20K6
  c include: ..\..\..\..\..\BSP\Driver\Include
  asm define: N9H20K6
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H20K6\N9H20K6.sct
  link misc: --entry 0
