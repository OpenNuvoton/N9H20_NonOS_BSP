# Keil uVision project N9H20K5_SpiWriter.uvproj, settings and files
target N9H20K5_QVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: N9H20K5_SpiWriter_QVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_QVGA_ __Security__
  c include: ..\..\..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
  group Src
    ../../Src/: DrawFont.c playsound.c ProcessIni.c spiflash.c wb_init.s standalone.c Writer.c
    ../: Rootkey.c ProcessOptionalIni.c
  group Lib
    ../../../../../BSP/Library/IPLib/: N9H20_GPIO.lib N9H20_SIC.lib N9H20_Font_QVGA.lib N9H20_Font_WQVGA.lib N9H20_Font_VGA.lib N9H20_Font_WVGA.lib N9H20_VPOST_GIANTPLUS_GPM1006D.lib N9H20_SPU.lib N9H20_SYS.lib N9H20_SPI_SecureIC.lib
    ../../../../../BSP/Library/NVTFATlib/: N9H20_NVTFAT.lib
target N9H20K5_WQVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_SpiWriter_WQVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WQVGA_ __Security__
  c include: ..\..\..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
target N9H20K5_VGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_SpiWriter_VGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_VGA_  __Security__
  c include: ..\..\..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
target N9H20K5_WVGA (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_SpiWriter_WVGA
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: _DEMO_WVGA_  __Security__
  c include: ..\..\..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
target N9H20K5_NoLCM (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: N9H20K5_SpiWriter_NoLCM
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 wLevel=2
  c define: __NoLCM__ __Security__
  c include: ..\..\..\..\..\BSP\Driver\Include
  asm define: N9H20K5
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: ..\..\..\..\..\BSP\Script\N9H20K5\N9H20K5.sct
  link misc: --entry 0
